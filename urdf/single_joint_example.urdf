Commit message: add joint limits config in urdf

File: urdf/single_joint_example.urdf (robot description, URDF)
Before this commit: robot single_joint_example, 2 links, 1 joints
Joints:
- joint axis: limit (none) -> effort=100. velocity=1.
